Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable]
File name: 0001
Time: 2022-04-06T08:06:43
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.21.45 - Exporter 21.1.21.45 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Apr 06 08:06:43 2022 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\9d881dba-9d9e-412a-a0ed-faa1918da4c5\a9e8514b-af62-4e31-8447-330e29212ac9\ifc * Database version: 5507 * Database creation date: Wed Apr 06 08:06:42 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Apr 06 08:06:43 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Apr 06 08:06:43 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 11780900_EU_APDR008:59520008_EU_11780900_APDR008, (2)
In: Default
Type - Pset_BuildingElementProxyCommon - Reference: 59520008_EU_11780900_APDR008
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_QuantityTakeOff - Reference: 59520008_EU_11780900_APDR008
Pset_BuildingElementProxyCommon - sets with these values: 2
